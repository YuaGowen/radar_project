# Keil uVision project presence_ulp.uvprojx, settings and files
target ramRun (6160000::V6.16::ARMCLANG)
  device: AT6010 Airtouch
  pack: Airtouch.AT60xx.0.1.0
  cpu: IRAM(0x20000000,0x30000) IROM(0x08000100,0x3FF00) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ramrun
  AfterMake: $KARM\ARMCLANG\bin\fromelf.exe #L --vhx --8x1 --output @L.hex --bin --output  out_ramrun\@L.bin
  AfterMake: $KARM\ARMCLANG\bin\fromelf.exe #L --text -a -c --output out_ramrun\@L_asm.txt
  c flags: Optim=6 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CORTEX_M0PLUS,  HAVE_TARGET_CONFIG_H, OSAL_SELECTION=OSAL_NOOS, ULP_PROG_2
  c misc: -Wno-shadow -Wno-bad-function-cast -Wno-missing-field-initializers -Wno-vla -Wno-missing-variable-declarations -Wno-strict-prototypes -Wno-dollar-in-identifier-extension -Wno-missing-noreturn -Wno-format-nonliteral -Wno-cast-align -Wno-cast-qual -Wno-shorten-64-to-32 -Wno-switch-enum -Wno-missing-prototypes -Wno-implicit-int-conversion -Wno-unused-parameter -Wno-extra-semi-stmt -Wno-gnu-zero-variadic-macro-arguments -Wno-sign-conversion -Wno-date-time -Wno-c11-extensions -Wno-variadic-macros -Wno-padded -Wno-covered-switch-default
  c include: ..\include;..\include\bw_500M;..\..\..\..\platform\arch\arm\chip\at6010;..\..\..\..\platform\arch\arm\cmsis\CMSIS\Include;..\..\..\..\platform\arch\arm\cmsis\Device\ARM\CMSDK_CM0plus\Include;..\..\..\..\platform\arch\arm\common\retarget;..\..\..\..\platform\arch\arm\include;..\..\..\..\platform\common\include;..\..\..\..\platform\drivers\include;..\..\..\..\platform\hal\include;..\..\..\..\platform\system\include;..\..\..\..\utils\include;..\..\..\..\utils\libc\include;..\..\..\..\utils\ci\include;..\..\..\..\utils\debug\atcmd\include;..\..\..\..\framework\afw\include;..\..\..\..\framework\alg\include;..\..\..\..\framework\mdetmgr\include;..\..\..\..\framework\radar\include;..\..\..\..\apps\app_light\include;..\..\..\..\apps\app_sensor_ulp\include;..\..\..\..\apps\common\include;..\..\..\..\apps\testmode\include;..\..\..\..\kernel\freertos;..\..\..\..\kernel\freertos\include;..\..\..\..\kernel\freertos\portable\GCC\ARM_CM0;..\..\..\..\kernel\osal\include;..\..\..\..\kernel\senos\core\include;..\..\..\..\utils\debug\cli\include;..\..\..\..\apps\shell\include;..\..\..\..\utils\debug\CmBacktrace;..\..\..\..\platform\ulp\include;..\..\..\..\apps\app_presense_ulp\include
  memory RVCT4: ROM 0x8000100 size 0x3ff00
  memory RVCT9: RAM 0x20000000 size 0x30000
  scatter file: .\ramrun.sct
  group app
    ../src/: main_presence_ulp.c ramrun_image.c
    ../../../../apps/common/src/: output_config.c handle_mdet_info.c sys_data.c version.c
    ../../../../apps/app_presense_ulp/src/: app_hpd_ulp.c
  group kernel
    ../../../../kernel/senos/core/: k_msg.c mem_heap.c
  group baremetal_osal
    ../../../../kernel/baremetal/: osal_common.c osal_event.c osal_memory.c osal_mutex.c osal_queue.c osal_sem.c osal_task.c osal_time.c osal_timer.c
  group framework/radar
    ../../../../framework/radar/src/: radar_profile_init.c
  group framework/mdet
    ../../../../framework/mdetmgr/src/: mdet_para_mgr.c
  group platform/ulp
    ../../../../platform/ulp/src/: ulp_mem.c
  group bsp
    ../../../../platform/system/armclang/: retarget.c
    ../../../../platform/system/time/: sys_timer.c
  group bsp_hal
    ../../../../platform/hal/src/: hal_timer.c hal_dualtimer.c hal_fft.c hal_clock.c hal_uart.c hal_radar.c
  group bsp_drv
    ../src/: at6010_irq.c
    ../../../../platform/drivers/time/: jiffies.c at6010_timer.c at6010_dualtimer.c
    ../../../../platform/drivers/gpio/: at6010_gpio.c
    ../../../../platform/drivers/clock/: at6010_clock.c
    ../../../../platform/drivers/uart/: at6010_uart.c
    ../../../../platform/drivers/pwm/: at6010_pwm.c
    ../../../../platform/drivers/wtd/: at6010_wtd.c
  group bsp_chip
    ../../../../platform/arch/arm/chip/at6010/: cpu-at601x.c
    ../../../../platform/arch/arm/cmsis/Device/ARM/CMSDK_CM0plus/Source/: system_CMSDK_CM0plus.c
    ./../src/: startup_CMSDK_CM0plus.s
  group utils
    ../../../../utils/libc/src/: vsprintf.c string.c ctype.c crc32.c bootrom_func.c
    ../../../../utils/fifo/: fifo.c
    ../../../../utils/log/: atlog.c
    ../../../../utils/mem/: at_malloc.c
  group libs
    ../../../../libs/: lib_alg_ulp_bhr.lib lib_platform.lib lib_radar.lib lib_eol.lib
  group utils/ci
    ../../../../utils/ci/src/: ci_cmd.c ci_main.c ci_port.c ci_ulp.c
  group eol
    ../../../../apps/testmode/eol/: app_eol.c ci_eol.c eol_radar_cfg.c
target flashRun (6160000::V6.16::ARMCLANG)
  device: AT6010 Airtouch
  pack: Airtouch.AT60xx.0.1.0
  cpu: as above
  output: flashrun
  BeforeMake: $PFlashRunPreBuild.bat
  AfterMake: $KARM\ARMCLANG\bin\fromelf.exe #L --vhx --8x1 --output @L.hex --bin --output  out_flashrun\@L.bin
  AfterMake: $KARM\ARMCLANG\bin\fromelf.exe #L --text -a -c --output out_flashrun\@L_asm.txt
  c flags: Optim=6 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CORTEX_M0PLUS,  HAVE_TARGET_CONFIG_H, OSAL_SELECTION=OSAL_NOOS, ULP_PROG_1
  c misc: as above
  c include: ..\include;..\include\bw_500M;..\..\..\..\platform\arch\arm\chip\at6010;..\..\..\..\platform\arch\arm\cmsis\CMSIS\Include;..\..\..\..\platform\arch\arm\cmsis\Device\ARM\CMSDK_CM0plus\Include;..\..\..\..\platform\arch\arm\common\retarget;..\..\..\..\platform\arch\arm\include;..\..\..\..\platform\common\include;..\..\..\..\platform\drivers\include;..\..\..\..\platform\hal\include;..\..\..\..\platform\system\include;..\..\..\..\utils\include;..\..\..\..\utils\libc\include;..\..\..\..\utils\ci\include;..\..\..\..\utils\debug\atcmd\include;..\..\..\..\framework\afw\include;..\..\..\..\framework\alg\include;..\..\..\..\framework\mdetmgr\include;..\..\..\..\framework\radar\include;..\..\..\..\apps\app_light\include;..\..\..\..\apps\app_sensor_ulp\include;..\..\..\..\apps\common\include;..\..\..\..\apps\testmode\include;..\..\..\..\kernel\freertos;..\..\..\..\kernel\freertos\include;..\..\..\..\kernel\freertos\portable\GCC\ARM_CM0;..\..\..\..\kernel\osal\include;..\..\..\..\kernel\senos\core\include;..\..\..\..\utils\debug\cli\include;..\..\..\..\apps\shell\include;..\..\..\..\utils\debug\CmBacktrace;..\..\..\..\platform\ulp\include;..\..\..\..\apps\app_presense_ulp\include;..\..\..\..\apps\testmode\eol;..\..\..\..\test\eol\include
  memory RVCT4: ROM 0x8000100 size 0x3ff00
  memory RVCT9: RAM 0x20000000 size 0x30000
  scatter file: .\flashrun.sct
