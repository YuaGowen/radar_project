# Keil uVision project sensor_1t2r.uvprojx, settings and files
target Release (6160000::V6.16::ARMCLANG)
  device: AT6010 Airtouch
  pack: Airtouch.AT60xx.0.1.0
  cpu: IRAM(0x20000000,0x30000) IROM(0x08000100,0x3FF00) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: sensor_1t2r
  AfterMake: $KARM\ARMCLANG\bin\fromelf.exe #L --vhx --8x1 --output @L.hex --bin --output out\@L.bin
  AfterMake: $K\ARM\ARMCLANG\BIN\fromelf.exe #L --text -a -c --output out\@L_asm.txt
  c flags: Optim=6 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CORTEX_M0PLUS,  HAVE_TARGET_CONFIG_H
  c misc: -Wno-shadow -Wno-bad-function-cast -Wno-missing-field-initializers -Wno-vla -Wno-missing-variable-declarations -Wno-strict-prototypes -Wno-dollar-in-identifier-extension -Wno-missing-noreturn -Wno-format-nonliteral -Wno-cast-align -Wno-cast-qual -Wno-shorten-64-to-32 -Wno-switch-enum -Wno-missing-prototypes -Wno-implicit-int-conversion -Wno-unused-parameter -Wno-extra-semi-stmt -Wno-gnu-zero-variadic-macro-arguments -Wno-sign-conversion -Wno-date-time -Wno-c11-extensions -Wno-variadic-macros -Wno-padded -Wno-covered-switch-default
  c include: ..\include;..\..\..\..\platform\arch\arm\chip\at6010;..\..\..\..\platform\arch\arm\cmsis\CMSIS\Include;..\..\..\..\platform\arch\arm\cmsis\Device\ARM\CMSDK_CM0plus\Include;..\..\..\..\platform\arch\arm\common\retarget;..\..\..\..\platform\arch\arm\include;..\..\..\..\platform\common\include;..\..\..\..\platform\drivers\include;..\..\..\..\platform\hal\include;..\..\..\..\platform\system\include;..\..\..\..\utils\include;..\..\..\..\utils\libc\include;..\..\..\..\utils\ci\include;..\..\..\..\utils\debug\atcmd\include;..\..\..\..\framework\afw\include;..\..\..\..\framework\alg\include;..\..\..\..\framework\mdetmgr\include;..\..\..\..\framework\radar\include;..\..\..\..\apps\app_light\include;..\..\..\..\apps\common\include;..\..\..\..\apps\testmode\include;..\..\..\..\kernel\freertos;..\..\..\..\kernel\freertos\include;..\..\..\..\kernel\freertos\portable\GCC\ARM_CM0;..\..\..\..\kernel\osal\include;..\..\..\..\kernel\senos\core\include;..\..\..\..\utils\debug\cli\include;..\..\..\..\apps\shell\include;..\..\..\..\utils\debug\CmBacktrace;..\..\..\..\apps\app_bt\include;..\..\..\..\apps\testmode\eol;..\..\..\..\test\eol\include
  memory RVCT4: ROM 0x8000100 size 0x3ff00
  memory RVCT9: RAM 0x20000000 size 0x30000
  scatter file: .\at6010_flashRun.sct
  group apps
    ../../../../apps/main/: main_os.c
    ../../../../apps/common/src/: dip_mgr.c light_ctrl.c version.c ir_process.c user_setting.c ir_para.c adc_key.c diagnose.c task_schedule.c app_init.c app_task.c if_data_output.c aux_adc_key.c sys_data.c output_config.c
  group apps_bt
    ../../../../apps/app_bt/src/: app_bt.c
  group apps_light
    ../../../../apps/app_light/src/: app_light.c
  group apps/testmode
    ../../../../apps/testmode/eol/: ci_eol.c app_eol.c eol_radar_cfg.c
    ../../../../apps/testmode/mod_test/: mod_test.c
    ../../../../apps/testmode/self_check/: self_check.c
    ../../../../apps/testmode/switch_tm/: switch_tm.c
  group shell
    ../../../../apps/shell/src/: shell.c bt_shell.c light_shell.c radar_shell.c radar_shell_impl.c
  group framework/afw
    ../../../../framework/afw/src/: init.c sys_task.c task_init.c wcn_task.c
  group framework/mdetmgr
    ../../../../framework/mdetmgr/src/: mdet_mgr.c mdet_para_mgr.c
  group framework/radar
    ../../../../framework/radar/src/: radar_mgr.c radar_profile_init.c radar_task.c
  group kernel
    ../../../../kernel/senos/core/: k_msg.c mem_heap.c
  group kernel_osal
    ../../../../kernel/osal/freertos/: osal_time.c osal_mutex.c osal_queue.c osal_sem.c osal_task.c osal_timer.c osal_mem.c osal_common.c osal_event.c
  group kernel_freertos
    ../../../../kernel/freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../kernel/freertos/portable/GCC/ARM_CM0/: port.c
    ../../../../kernel/freertos/portable/MemMang/: heap_4.c
    ../../../../kernel/freertos/portable/run_time_stats/: run_time_stats.c
  group bsp
    ../../../../platform/system/armclang/: retarget.c
    ../../../../platform/system/time/: sys_timer.c
  group bsp_hal
    ../../../../platform/hal/src/: hal_common.c hal_timer.c hal_light.c hal_dip.c hal_ls.c hal_ir.c hal_key.c hal_dualtimer.c hal_fft.c hal_radar_fmcw.c hal_clock.c hal_random.c hal_uart.c hal_aux_key.c hal_radar.c hal_relay.c
  group bsp_drv
    ../../../../platform/drivers/ir/: ir_decode.c
    ../../../../platform/drivers/time/: jiffies.c at6010_timer.c at6010_dualtimer.c
    ../../../../platform/drivers/irq/: at6010_irq.c
    ../../../../platform/drivers/gpio/: at6010_gpio.c
    ../../../../platform/drivers/clock/: at6010_clock.c
    ../../../../platform/drivers/i2c/: at6010_i2c_host.c
    ../../../../platform/drivers/uart/: at6010_uart.c
    ../../../../platform/drivers/pwm/: at6010_pwm.c
    ../../../../platform/drivers/wtd/: at6010_wtd.c
    ../../../../platform/drivers/mpu/: at6010_mpu.c
    ../../../../platform/common/freq_measure/: frequency_measure.c
  group bsp_chip
    ../../../../platform/arch/arm/chip/at6010/: cpu-at601x.c
    ../../../../platform/arch/arm/cmsis/Device/ARM/CMSDK_CM0plus/Source/: system_CMSDK_CM0plus.c
    ../../../../platform/arch/arm/cmsis/Device/ARM/CMSDK_CM0plus/Source/ARM/: startup_CMSDK_CM0plus.s
  group utils
    ../../../../utils/libc/src/: vsprintf.c string.c ctype.c crc32.c bootrom_func.c
    ../../../../utils/fifo/: fifo.c
    ../../../../utils/log/: atlog.c
  group utils_ci
    ../../../../utils/ci/src/: ci_cmd.c ci_main.c ci_port.c
  group utils_atcmd
    ../../../../utils/debug/atcmd/src/: atcmd_handler.c atcmd_task.c console_task.c
  group utils_cmbacktrace
    ../../../../utils/debug/CmBacktrace/: cm_backtrace.c
    ../../../../utils/debug/CmBacktrace/fault_handler/keil/: cmb_fault.S
  group utils_cli
    ../../../../utils/debug/cli/: FreeRTOS_CLI.c make_argv.c Sample-CLI-commands.c UARTCommandConsole.c serial.c
  group libs
    ../../../../libs/: lib_alg_fmcw.lib lib_platform.lib lib_radar.lib lib_eol.lib
