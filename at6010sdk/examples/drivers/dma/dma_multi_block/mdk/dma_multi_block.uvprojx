# Keil uVision project dma_multi_block.uvprojx, settings and files
target Debug (6160000::V6.16::ARMCLANG)
  device: AT6010 Airtouch
  pack: Airtouch.AT60xx.0.1.0
  cpu: IRAM(0x20000000,0x30000) IROM(0x08000100,0x3FF00) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: dma_multi_block
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe #L --vhx --8x1 --output @L.hex --bin --output out\@L.bin
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe #L --text -a -c --output out\@L.txt
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CORTEX_M0PLUS
  c include: ..\..\..\..\..\platform\arch\arm\cmsis\CMSIS\Include;..\..\..\..\..\platform\arch\arm\cmsis\Device\ARM\CMSDK_CM0plus\Include;..\..\..\..\..\platform\arch\arm\common\retarget;..\..\..\..\..\platform\arch\arm\chip\at6010;..\..\..\..\..\platform\arch\arm\include;..\..\..\..\..\platform\common\include;..\..\..\..\..\platform\drivers\include;..\..\..\..\..\platform\hal\include
  library: MicroLIB
  memory RVCT1: ROM 0x20000000 size 0x2000
  memory RVCT4: ROM 0x8000100 size 0x3ff00
  memory RVCT6: RAM 0x20002000 size 0x2000
  scatter file: .\demo.sct
  link misc: --diag_suppress L6314,L6329
  group Startup
    ../../../../../platform/arch/arm/cmsis/Device/ARM/CMSDK_CM0plus/Source/ARM/: startup_CMSDK_CM0plus.s
  group Application
    ../src/: dma_multi_block.c at6010_it.c
  group System
    ../../../../../platform/system/armclang/: retarget.c
    ../../../../../platform/arch/arm/cmsis/Device/ARM/CMSDK_CM0plus/Source/: system_CMSDK_CM0plus.c
  group Hal
    ../../../../../platform/hal/src/: hal_uart.c hal_dualtimer.c hal_dma.c
  group Driver
    ../../../../../platform/drivers/clock/: at6010_clock.c
    ../../../../../platform/drivers/uart/: at6010_uart.c
    ../../../../../platform/drivers/time/: at6010_dualtimer.c
    ../../../../../platform/drivers/gpio/: at6010_gpio.c
  group Lib
    ../../../../../libs/: lib_platform.lib
target Ramrun (6160000::V6.16::ARMCLANG)
  device: AT6010 Airtouch
  pack: Airtouch.AT60xx.0.1.0
  cpu: as above
  output: dma_multi_block_ramrun
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe #L --vhx --8x1 --output hello.hex --bin --output out\dma_multi_block.bin
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe #L --text -a -c --output out\dma_multi_block_asm.txt
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CORTEX_M0PLUS
  c include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x20000000 size 0x2000
  memory RVCT4: ROM 0x8000100 size 0x3ff00
  memory RVCT6: RAM 0x20002000 size 0x2000
  link misc: --diag_suppress L6314,L6329
