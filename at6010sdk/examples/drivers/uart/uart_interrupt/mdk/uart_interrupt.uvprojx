# Keil uVision project uart_interrupt.uvprojx, settings and files
target Debug (6160000::V6.16::ARMCLANG)
  device: AT6010 Airtouch
  pack: Airtouch.AT60xx.0.1.0
  cpu: IRAM(0x20000000,0x30000) IROM(0x08000100,0x3FF00) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: uart_interrupt
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe #L --vhx --8x1 --output uart_interrupt.hex --bin --output out\uart_interrupt.bin
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe #L --text -a -c --output out\uart_interrupt_asm.txt
  c flags: Optim=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CORTEX_M0PLUS,CHIP_AT6010_U01
  c include: ..\..\..\..\..\platform\arch\arm\cmsis\CMSIS\Include;..\..\..\..\..\platform\arch\arm\cmsis\Device\ARM\CMSDK_CM0plus\Include;..\..\..\..\..\platform\arch\arm\common\retarget;..\..\..\..\..\platform\arch\arm\chip\at6010;..\..\..\..\..\platform\arch\arm\include;..\..\..\..\..\platform\common\include;..\..\..\..\..\platform\drivers\include;..\..\..\..\..\platform\hal\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000100 size 0x3ff00
  memory RVCT9: RAM 0x20000000 size 0x30000
  scatter file: .\at6010_flashRun.sct
  group Startup
    ../../../../../platform/arch/arm/cmsis/Device/ARM/CMSDK_CM0plus/Source/ARM/: startup_CMSDK_CM0plus.s
  group Application
    ../src/: uart_interrupt.c
  group System
    ../../../../../platform/arch/arm/cmsis/Device/ARM/CMSDK_CM0plus/Source/: system_CMSDK_CM0plus.c
    ../../../../../platform/arch/arm/chip/at6010/: cpu-at601x.c
  group Hal
    ../../../../../platform/hal/src/: hal_clock.c hal_uart.c hal_dualtimer.c
  group Driver
    ../../../../../platform/drivers/uart/: at6010_uart.c
    ../../../../../platform/drivers/clock/: at6010_clock.c
    ../src/: at6010_irq_uart_interrupt.c
    ../../../../../platform/drivers/time/: at6010_dualtimer.c
    ../../../../../platform/drivers/gpio/: at6010_gpio.c
  group Lib
    ../../../../../libs/: lib_platform.lib
