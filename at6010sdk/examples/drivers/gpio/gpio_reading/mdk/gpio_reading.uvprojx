# Keil uVision project gpio_reading.uvprojx, settings and files
target Debug (6160000::V6.16::ARMCLANG)
  device: AT6010 Airtouch
  pack: Airtouch.AT60xx.0.1.0
  cpu: IRAM(0x20000000,0x30000) IROM(0x08000100,0x3FF00) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: gpio_reading
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe #L --vhx --8x1 --output gpio_reading.hex --bin --output out\gpio_reading.bin
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe #L --text -a -c --output out\gpio_reading_asm.txt
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CORTEX_M0PLUS
  c include: ..\..\..\..\..\platform\arch\arm\chip\at6010;..\..\..\..\..\platform\arch\arm\cmsis\CMSIS\Include;..\..\..\..\..\platform\arch\arm\cmsis\Device\ARM\CMSDK_CM0plus\Include;..\..\..\..\..\platform\arch\arm\include;..\..\..\..\..\platform\common\include;..\..\..\..\..\platform\drivers\include;..\..\..\..\..\platform\hal\include
  library: MicroLIB
  memory RVCT1: ROM 0x20000000 size 0x4000
  memory RVCT4: ROM 0x8000100 size 0x3ff00
  memory RVCT6: RAM 0x20004000 size 0x4000
  scatter file: .\demo.sct
  link misc: --diag_suppress L6314,L6329
  group Startup
    ../../../../../platform/arch/arm/cmsis/Device/ARM/CMSDK_CM0plus/Source/ARM/: startup_CMSDK_CM0plus.s
  group App
    ../src/: gpio_reading.c
    ../../../../../platform/system/armclang/: retarget.c
  group System
    ../../../../../platform/arch/arm/cmsis/Device/ARM/CMSDK_CM0plus/Source/: system_CMSDK_CM0plus.c
  group Hal
    ../../../../../platform/hal/src/: hal_uart.c hal_dualtimer.c
  group Driver
    ../../../../../platform/drivers/gpio/: at6010_gpio.c
    ../../../../../platform/drivers/clock/: at6010_clock.c
    ../../../../../platform/drivers/uart/: at6010_uart.c
    ../../../../../platform/drivers/time/: at6010_dualtimer.c
target Ramrun (6160000::V6.16::ARMCLANG)
  device: AT6010 Airtouch
  pack: Airtouch.AT60xx.0.1.0
  cpu: as above
  output: gpio_reading
  AfterMake: as above
  AfterMake: as above
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CORTEX_M0PLUS
  c include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x20000000 size 0x4000
  memory RVCT4: ROM 0x8000100 size 0x3ff00
  memory RVCT6: RAM 0x20004000 size 0x4000
  link misc: --diag_suppress L6314,L6329
