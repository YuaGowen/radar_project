# Keil uVision project rawdata_base.uvprojx, settings and files
target BW_1G (6160000::V6.16::ARMCLANG)
  device: AT6010 Airtouch
  pack: Airtouch.AT60xx.0.1.0
  cpu: IRAM(0x20000000,0x30000) IROM(0x08000100,0x3FF00) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: rawdata_base +hex
  AfterMake: $K\ARM\ARMCLANG\bin\fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CORTEX_M0PLUS,HAL_UART_DMA_EN
  c include: ..\include;..\include\bw_1G;..\src;..\..\..\..\..\platform\arch\arm\cmsis\CMSIS\Include;..\..\..\..\..\platform\arch\arm\cmsis\Device\ARM\CMSDK_CM0plus\Include;..\..\..\..\..\platform\arch\arm\common\retarget;..\..\..\..\..\platform\arch\arm\chip\at6010;..\..\..\..\..\platform\arch\arm\include;..\..\..\..\..\platform\common\include;..\..\..\..\..\platform\drivers\include;..\..\..\..\..\platform\hal\include;..\..\..\..\..\framework\radar\include;..\..\..\..\..\platform\arch\arm\chip\at6010;..\..\..\..\..\utils\include
  memory RVCT4: ROM 0x8000100 size 0x3ff00
  memory RVCT9: RAM 0x20000000 size 0x30000
  scatter file: .\at6010_flashRun.sct
  group Startup
    ./: startup_CMSDK_CM0plus.s
  group Application
    ../src/: rawdata_base_main.c radar_cfg_hal.c
    ../../../../../platform/system/armclang/: retarget.c
  group System
    ../../../../../platform/arch/arm/cmsis/Device/ARM/CMSDK_CM0plus/Source/: system_CMSDK_CM0plus.c
  group Hal
    ../../../../../platform/hal/src/: hal_dualtimer.c hal_clock.c hal_uart.c hal_fft.c hal_radar.c hal_timer.c hal_dma.c hal_spi.c
  group Driver
    ../../../../../platform/drivers/time/: at6010_dualtimer.c at6010_timer.c
    ../../../../../platform/drivers/uart/: at6010_uart.c
    ../../../../../platform/drivers/clock/: at6010_clock.c
    ../src/: at6010_irq.c
    ../../../../../platform/drivers/gpio/: at6010_gpio.c
    ../../../../../platform/arch/arm/chip/at6010/: cpu-at601x.c
  group Radar
    ../src/: output_config.c frame_header.c
  group Lib
    ../../../../../libs/: lib_platform.lib lib_radar.lib
target BW_5G (6120000::V6.12::.\ARMCLANG)
  device: AT6010 Airtouch
  pack: Airtouch.AT60xx.0.1.0
  cpu: as above
  output: rawdata_base +hex
  AfterMake: $K\ARM\ARMCLANG\bin\fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CORTEX_M0PLUS HAL_UART_DMA_EN CHIP_AT6010_U01
  c include: ..\include;..\include\bw_5G;..\src;..\..\..\..\..\platform\arch\arm\cmsis\CMSIS\Include;..\..\..\..\..\platform\arch\arm\cmsis\Device\ARM\CMSDK_CM0plus\Include;..\..\..\..\..\platform\arch\arm\common\retarget;..\..\..\..\..\platform\arch\arm\chip\at6010;..\..\..\..\..\platform\arch\arm\include;..\..\..\..\..\platform\common\include;..\..\..\..\..\platform\drivers\include;..\..\..\..\..\platform\hal\include;..\..\..\..\..\framework\radar\include;..\..\..\..\..\utils\include
  memory RVCT4: ROM 0x8000100 size 0x3ff00
  memory RVCT9: RAM 0x20000000 size 0x30000
  scatter file: .\at6010_flashRun.sct
