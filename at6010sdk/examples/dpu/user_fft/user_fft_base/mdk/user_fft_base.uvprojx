# Keil uVision project user_fft_base.uvprojx, settings and files
target user_fft_base (6160000::V6.16::ARMCLANG)
  device: AT6010 Airtouch
  pack: Airtouch.AT60xx.0.1.0
  cpu: IRAM(0x20000000,0x30000) IROM(0x08000100,0x3FF00) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: user_fft_base +hex
  AfterMake: $K\ARM\ARMCLANG\bin\fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CORTEX_M0PLUS, FFT_DEMO_TYPE=0, HAL_UART_DMA_EN
  c include: ..\include;..\..\..\..\..\platform\arch\arm\cmsis\CMSIS\Include;..\..\..\..\..\platform\arch\arm\cmsis\Device\ARM\CMSDK_CM0plus\Include;..\..\..\..\..\platform\arch\arm\common\retarget;..\..\..\..\..\platform\arch\arm\chip\at6010;..\..\..\..\..\platform\arch\arm\include;..\..\..\..\..\platform\common\include;..\..\..\..\..\platform\drivers\include;..\..\..\..\..\platform\hal\include;..\..\..\..\..\utils\include
  memory RVCT1: ROM 0x20000000 size 0x8000
  memory RVCT4: ROM 0x8000100 size 0x3ff00
  memory RVCT6: RAM 0x20008000 size 0xb000
  scatter file: .\at6010_flashRun.sct
  group Startup
    ../../../../../platform/arch/arm/cmsis/Device/ARM/CMSDK_CM0plus/Source/ARM/: startup_CMSDK_CM0plus.s
  group Application
    ../src/: user_fft_base_main.c frame_header.c output_config.c
  group System
    ../../../../../platform/arch/arm/cmsis/Device/ARM/CMSDK_CM0plus/Source/: system_CMSDK_CM0plus.c
  group Drivers
    ../../../../../platform/drivers/time/: at6010_dualtimer.c at6010_timer.c
    ../../../../../platform/drivers/clock/: at6010_clock.c
    ../../../../../platform/drivers/gpio/: at6010_gpio.c
    ../../../../../platform/drivers/uart/: at6010_uart.c
    ../src/: at6010_irq.c
    ../../../../../platform/arch/arm/chip/at6010/: cpu-at601x.c
  group Retarget
    ../../../../../platform/system/armclang/: retarget.c
  group HAL
    ../../../../../platform/hal/src/: hal_uart.c hal_fft.c hal_dualtimer.c hal_timer.c hal_clock.c hal_dma.c
  group Lib
    ../../../../../libs/: lib_platform.lib lib_radar.lib
