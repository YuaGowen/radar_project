# Keil uVision project dualtimer.uvprojx, settings and files
target Debug (6160000::V6.16::ARMCLANG)
  device: AT6010 Airtouch
  pack: Airtouch.AT60xx.0.1.0
  cpu: IRAM(0x20000000,0x30000) IROM(0x08000100,0x3FF00) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: dualtimer
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe #L --vhx --8x1 --output out\dualtimer.hex --bin --output out\dualtimer.bin
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe #L --text -a -c --output out\dualtimer.txt
  c flags: Optim=2 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CORTEX_M0PLUS
  c include: ..\..\..\..\..\platform\arch\arm\cmsis\CMSIS\Include;..\..\..\..\..\platform\arch\arm\cmsis\Device\ARM\CMSDK_CM0plus\Include;..\..\..\..\..\platform\arch\arm\common\retarget;..\..\..\..\..\platform\drivers\include;..\..\..\..\..\platform\arch\arm\chip\at6010;..\..\..\..\..\platform\common\include;..\..\..\..\..\platform\arch\arm\include;..\..\..\..\..\platform\hal\include
  asm define: CORTEX_M0PLUS,SYS_CLK_FREQ=52000000
  library: MicroLIB
  memory RVCT1: ROM 0x20000000 size 0x4000
  memory RVCT4: ROM 0x8000100 size 0x3ff00
  memory RVCT6: RAM 0x20004000 size 0x4000
  scatter file: .\demo.sct
  link misc: --diag_suppress L6314,L6329
  group Startup
    ../../../../../platform/arch/arm/cmsis/Device/ARM/CMSDK_CM0plus/Source/ARM/: startup_CMSDK_CM0plus.s
  group Application
    ../src/: dualtimer_sample.c at6010_irq_dualtimer.c
  group System
    ../../../../../platform/arch/arm/cmsis/Device/ARM/CMSDK_CM0plus/Source/: system_CMSDK_CM0plus.c
    ../../../../../platform/system/armclang/: retarget.c
  group Hal
    ../../../../../platform/hal/src/: hal_clock.c hal_dualtimer.c hal_uart.c
  group Driver
    ../../../../../platform/drivers/clock/: at6010_clock.c
    ../../../../../platform/drivers/time/: at6010_dualtimer.c
    ../../../../../platform/drivers/uart/: at6010_uart.c
    ../../../../../platform/drivers/gpio/: at6010_gpio.c
  group Lib
    ../../../../../libs/: lib_platform.lib
