# Keil uVision project range_fft_base.uvprojx, settings and files
target BW_1G (6160000::V6.16::ARMCLANG)
  device: AT6010 Airtouch
  pack: Airtouch.AT60xx.0.1.0
  cpu: IRAM(0x20000000,0x30000) IROM(0x08000100,0x3FF00) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: range_fft_base +hex
  AfterMake: $K\ARM\ARMCLANG\BIN\fromelf.exe #L --vhx --8x1 --output radar_test.hex --bin --output out\radar_test.bin
  AfterMake: $K\ARM\ARMCLANG\BIN\fromelf.exe #L --text -a -c --output out\radar_test.txt
  c flags: Optim=6 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CORTEX_M0PLUS,UART1_PINMUX_SEL_X=UART1_PINMUX_SEL_3,HAL_UART_DMA_EN,UART2_PINMUX_SEL_X = UART2_PINMUX_SEL_1
  c include: ..\include;..\include\bw_1G;..\src;..\..\..\..\..\platform\arch\arm\cmsis\CMSIS\Include;..\..\..\..\..\platform\arch\arm\cmsis\Device\ARM\CMSDK_CM0plus\Include;..\..\..\..\..\platform\arch\arm\common\retarget;..\..\..\..\..\platform\arch\arm\chip\at6010;..\..\..\..\..\platform\arch\arm\include;..\..\..\..\..\platform\common\include;..\..\..\..\..\platform\drivers\include;..\..\..\..\..\platform\hal\include;..\..\..\..\..\utils\include
  memory RVCT4: ROM 0x8000100 size 0x3ff00
  memory RVCT9: RAM 0x20000000 size 0x30000
  scatter file: .\at6010_flashRun.sct
  group Startup
    ./: startup_CMSDK_CM0plus.s
  group Application
    ../../../../../platform/system/armclang/: retarget.c
    ../src/: range_fft_base_main.c
  group System
    ../../../../../platform/arch/arm/cmsis/Device/ARM/CMSDK_CM0plus/Source/: system_CMSDK_CM0plus.c
  group Hal
    ../../../../../platform/hal/src/: hal_clock.c hal_uart.c hal_fft.c hal_radar.c hal_timer.c hal_dualtimer.c hal_dma.c hal_spi.c
    ../src/: radar_cfg_hal.c
  group Driver
    ../../../../../platform/drivers/uart/: at6010_uart.c
    ../../../../../platform/drivers/clock/: at6010_clock.c
    ../src/: at6010_irq.c
    ../../../../../platform/drivers/gpio/: at6010_gpio.c
    ../../../../../platform/arch/arm/chip/at6010/: cpu-at601x.c
    ../../../../../platform/drivers/time/: at6010_timer.c at6010_dualtimer.c
  group Radar
    ../src/: output_config.c frame_header.c
  group Lib
    ../../../../../libs/: lib_platform.lib lib_radar.lib
target BW_5G (6120000::V6.12::.\ARMCLANG)
  device: AT6010 Airtouch
  pack: Airtouch.AT60xx.0.1.0
  cpu: as above
  output: range_fft_base +hex
  AfterMake: as above
  AfterMake: as above
  c flags: Optim=6 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: as above
  c include: ..\include;..\include\bw_5G;..\src;..\..\..\..\..\platform\arch\arm\cmsis\CMSIS\Include;..\..\..\..\..\platform\arch\arm\cmsis\Device\ARM\CMSDK_CM0plus\Include;..\..\..\..\..\platform\arch\arm\common\retarget;..\..\..\..\..\platform\arch\arm\chip\at6010;..\..\..\..\..\platform\arch\arm\include;..\..\..\..\..\platform\common\include;..\..\..\..\..\platform\drivers\include;..\..\..\..\..\platform\hal\include;..\..\..\..\..\utils\include
  memory RVCT4: ROM 0x8000100 size 0x3ff00
  memory RVCT9: RAM 0x20000000 size 0x30000
  scatter file: .\at6010_flashRun.sct
