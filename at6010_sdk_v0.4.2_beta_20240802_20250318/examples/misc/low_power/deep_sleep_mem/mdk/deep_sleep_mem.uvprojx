# Keil uVision project deep_sleep_mem.uvprojx, settings and files
target ramRun (6160000::V6.16::ARMCLANG)
  device: AT6010 Airtouch
  pack: Airtouch.AT60xx.0.1.0
  cpu: IRAM(0x20000000,0x30000) IROM(0x08000100,0x3FF00) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ramrun +hex
  AfterMake: $KARM\ARMCLANG\bin\fromelf.exe #L --vhx --8x1 --output @L.hex --bin --output  out_ramrun\@L.bin
  AfterMake: $KARM\ARMCLANG\bin\fromelf.exe #L --text -a -c --output out_ramrun\@L_asm.txt
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CORTEX_M0PLUS, HAVE_TARGET_CONFIG_H, OSAL_SELECTION=OSAL_NOOS, ULP_PROG_2,SWEEP_400M
  c include: ..\include;..\include\bw_400M;..\..\..\..\..\platform\arch\arm\cmsis\CMSIS\Include;..\..\..\..\..\platform\arch\arm\cmsis\Device\ARM\CMSDK_CM0plus\Include;..\..\..\..\..\platform\arch\arm\common\retarget;..\..\..\..\..\platform\arch\arm\chip\at6010;..\..\..\..\..\platform\arch\arm\include;..\..\..\..\..\platform\common\include;..\..\..\..\..\platform\drivers\include;..\..\..\..\..\platform\hal\include;..\..\..\..\..\utils\include;..\..\..\..\..\platform\system\include;..\..\..\..\..\kernel\senos\core\include;..\..\..\..\..\utils\libc\include;..\..\..\..\..\kernel\osal\include;..\..\..\..\..\platform\ulp\include
  memory RVCT1: ROM 0x20000000 size 0x4000
  memory RVCT4: ROM 0x8000100 size 0x3ff00
  memory RVCT6: RAM 0x20004000 size 0x4000
  scatter file: .\ramrun.sct
  link misc: --diag_suppress L6314,L6329
  group Application
    ../src/: deep_sleep_mem_main.c ramrun_image.c at6010_irq.c frame_header.c output_config.c radar_cfg_hal.c
    ../include/: deep_sleep_mem_main.h
  group CommonCFG
    ../include/: cfg_aux_key.h cfg_calib.h cfg_dip_switch.h cfg_ir.h cfg_key.h cfg_log.h target_config.h bytestream.h clk_cfg.h frame_header.h output_config.h radar_fmcw.h
  group Startup
    ./: startup_CMSDK_CM0plus.s
    ../src/: system_CMSDK_CM0plus.c
    ../../../../../platform/arch/arm/chip/at6010/: cpu-at601x.c
  group Driver
    ../../../../../platform/drivers/clock/: at6010_clock.c
    ../../../../../platform/drivers/time/: at6010_dualtimer.c at6010_timer.c jiffies.c
    ../../../../../platform/drivers/uart/: at6010_uart.c
    ../../../../../platform/drivers/gpio/: at6010_gpio.c
    ../../../../../platform/drivers/i2c/: at6010_i2c_host.c
    ../../../../../platform/drivers/ir/: ir_decode.c
    ../../../../../platform/drivers/light/: at6010_light.c
    ../../../../../platform/drivers/pwm/: at6010_pwm.c
    ../../../../../platform/drivers/wtd/: at6010_wtd.c
  group Hal
    ../../../../../platform/hal/src/: hal_dualtimer.c hal_uart.c hal_clock.c hal_dma.c hal_fft.c hal_ir.c hal_light.c hal_ls.c hal_radar.c hal_random.c hal_relay.c hal_timer.c hal_spi.c
  group Utils
    ../../../../../utils/log/: atlog.c
    ../../../../../utils/libc/src/: crc32.c ctype.c string.c vsprintf.c
    ../../../../../utils/mem/: at_malloc.c
  group Bsp
    ../../../../../platform/system/time/: sys_timer.c
    ../../../../../platform/system/armclang/: retarget.c
  group Libs
    ../../../../../libs/: lib_alg_fmcw.lib lib_platform.lib lib_radar.lib
  group Kernel/Senos
    ../../../../../kernel/senos/core/: k_msg.c mem_heap.c
  group Kernel/Baremetal
    ../../../../../kernel/baremetal/: osal_common.c osal_event.c osal_memory.c osal_mutex.c osal_queue.c osal_sem.c osal_task.c osal_time.c osal_timer.c
  group Platform
    ../../../../../platform/ulp/src/: ulp_mem.c
target flashRun (6160000::V6.16::ARMCLANG)
  device: AT6010 Airtouch
  pack: Airtouch.AT60xx.0.1.0
  cpu: as above
  output: flashrun +hex
  BeforeMake: $PFlashRunPreBuild.bat
  AfterMake: $KARM\ARMCLANG\bin\fromelf.exe #L --vhx --8x1 --output @L.hex --bin --output  out_flashrun\@L.bin
  AfterMake: $KARM\ARMCLANG\bin\fromelf.exe #L --text -a -c --output  out_flashrun\@L.asm.txt
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CORTEX_M0PLUS, HAVE_TARGET_CONFIG_H, OSAL_SELECTION=OSAL_NOOS, ULP_PROG_1, SWEEP_400M
  c include: as above
  memory RVCT1: ROM 0x20000000 size 0x4000
  memory RVCT4: ROM 0x8000100 size 0x3ff00
  memory RVCT6: RAM 0x20004000 size 0x4000
  scatter file: .\flashrun.sct
  link misc: --diag_suppress L6314,L6329
